# Keil uVision project Nucleic acid extraction.uvproj, settings and files
target Target 1 (MCS-51)
  device: ADuC847 Analog Devices
  cpu: IRAM(0-0xFF) XRAM(0-0x7FF) IROM(0-0xF7FF) CLOCK(32768) DPX MODAB2
  output: DC +hex
  c flags: Optimize=8 SizeSpeed=1
  group mian
    ./: Main.c
